# Keil uVision project stm32f103.uvprojx, settings and files
target project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32f103
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\app;..\driver;..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;.\FreeRTOS;.\FreeRTOS\inc;.\FreeRTOS\port;.\FreeRTOS\src;..\driver\mpu6050;..\driver\st7735;..\core;..\Game
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group core
    ../core/: main.c main.h display.c display.h game .h game.c input.c input.h cpnfig.c config.h
    ./FreeRTOS/: freertos_demo.c freertos_demo.h
  group Game
    ../Game/: image.c image.h map.c map.h tank.c tank.h bullet.c bullet.h
  group app
    ../firmware/cmsis/device/: stm32f10x_it.c stm32f10x_it.h
    ../app/: led.c led.h key.c key.h exit.c exit.h USART.c USART.h lcd.c lcd.h Delay.c Delay.h swi2c.c swi2c.h
  group driver
    ../driver/mpu6050/: mpu6050.c mpu6050.h
    ../driver/st7735/: st7735.c st7735.h stfonts.c stfonts.h stimage.c stimage.h
  group firmware
    ../firmware/cmsis/device/: startup_stm32f10x_md.s system_stm32f10x.c
    ../firmware/cmsis/core/: core_cm3.c
    ../firmware/driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group FreeRTOS/src
    ./FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/inc
    ./FreeRTOS/: FreeRTOSConfig.h
    ./FreeRTOS/inc/: croutine.h deprecated_definitions.h event_groups.h FreeRTOS.h list.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h StackMacros.h task.h timers.h
  group FreeRTOS/port
    ./FreeRTOS/port/: heap_4.c port.c
